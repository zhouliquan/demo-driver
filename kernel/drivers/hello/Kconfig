## kernel/drivers/hello/Kconfig
```kconfig
config HELLO
    tristate "First Android Driver"
    default n
    help
    this is the first android driver.
```
